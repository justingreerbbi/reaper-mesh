## firmware/t1000-e/boards/seeed/t1000_e/board.yml
```yaml
board:
  name: t1000_e
  full_name: Seeed SenseCAP Card Tracker T1000-E
  vendor: seeed
  socs:
    - name: nrf52840
```
